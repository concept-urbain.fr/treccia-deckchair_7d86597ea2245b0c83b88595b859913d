Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Chilienne Treccia.IFC
Time: 2023-07-26T07:47:36
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 106301_Default (2)
In: Default Storey
Name
106301_Default | PSet_Mass_Property - Mass Measure: 50.6996; Area Measure: 3.50556 m2; Volume Measure: 0.00658436 m3
106301_Default
